# IAR project Valvola 3 Vie Lavatrice.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE02Z64xxx4 NXP MKE02Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE02Z64VQH4; FRDM_KE02Z40M; FREEDOM; ENABLE_RAM_VECTOR_TABLE; MCUXPRESSO_SDK; ENABLE_RAM_VECTOR_TABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; board; CMSIS; Device; drivers; source; startup; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: Valvola 3 Vie Lavatrice.srec
  ILINK.IlinkOutputFile: Valvola 3 vie.out
  ILINK.IlinkIcfFile: MKE02Z64xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE02Z64VQH4; FRDM_KE02Z40M; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MKE02Z4/utilities/str; ../../../../../../devices/MKE02Z4/utilities/debug_console_lite; ../../../../../../devices/MKE02Z4/drivers; ../../../../../../devices/MKE02Z4; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkOutputFile: gpio_1_led_output.out
  group (top)
    ./: MKE02Z64xxx4_flash.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group device
    Device/: fsl_device_registers.h MKE02Z4.h MKE02Z4_features.h system_MKE02Z4.c system_MKE02Z4.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_kbi.c fsl_kbi.h fsl_port.c fsl_port.h
  group source
    source/: switch.c switch.h Valvola 3 Vie Lavatrice.c
  group startup
    startup/: startup_MKE02Z4.s
