<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>Valvola 3 Vie Lavatrice</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>Valvola 3 Vie Lavatrice</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>Valvola 3 Vie Lavatrice</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>Valvola 3 Vie Lavatrice</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/Valvola 3 Vie Lavatrice.ewp</path>
  </project>
</workspace>
